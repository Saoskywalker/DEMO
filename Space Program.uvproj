# Keil uVision project Space Program.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Demo +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  .\OUTPUT\Demo.bin .\OUTPUT\Demo.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\ST_Inc;.\User_Inc;.\Library\dwDrive;.\Library\dwDriveD2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ST_Src
    ./ST_Src/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_tim.c stm32f10x_usart.c system_stm32f10x.c startup_stm32f10x_md.s stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_flash.c
  group User_Src
    ./User_Src/: delay.c main.c sys.c timer.c usart.c wdg.c UserBaseLib.c AppLib.c adc.c stmflash.c pad_com.c
  group Library
    ./Library/dwDriveD2/: dwDriveD2.c
